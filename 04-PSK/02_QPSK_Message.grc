options:
  parameters:
    generate_options: qt_gui
    id: QPSK_message
    output_language: python
    title: QPSK_message
  states: {}

blocks:
- name: LO_Range
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    orient: Qt.Horizontal
    start: '-10e3'
    step: '100'
    stop: 10e3
    value: '0'
  states: {}
- name: RX_Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: '100'
    value: '70'
  states: {}
- name: TX_Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: '100'
    value: '70'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: cut_off
  id: variable_qtgui_range
  parameters:
    label: cut_off
    orient: Qt.Horizontal
    start: 1e3
    step: '100'
    stop: 100e3
    value: 10e3
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable_qtgui_range
  parameters:
    label: transition
    orient: Qt.Horizontal
    start: 1e3
    step: '100'
    stop: 100e3
    value: 1e3
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: LO_Range
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 1, 0, 0)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: byte
    out_type: complex
    symbol_table: (1+1j, -1+1j, 1-1j, -1-1j)
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: center_freq
    gain0: TX_Gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@2
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    gui_hint: tabs@0
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq-LO_Range
    fftsize: '1024'
    gui_hint: tabs@1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@0
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@1
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: 1_tx_input
    label1: 2_rx_received
    label2: 3_const_input
    label3: 4_time_input
    label4: 5_freq_mult
    label5: 6_results
    num_tabs: '6'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: RX_Gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_repeat_0, '0', osmosdr_sink_0, '0']
- [blocks_repeat_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
